## Kconfig
```kconfig
config usb-can-hlcan
        tristate "hlcan module for usb-can"
        depends on USB
        help
          Help message of usb-can-hlcan
```
